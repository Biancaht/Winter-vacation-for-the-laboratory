# Keil uVision project 实验1：点亮LED灯.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 实验1：点亮LED灯 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 实验1：点亮LED灯.c
  group Group 2
    ../实验2/: 实验2：闪烁（延时）.c
